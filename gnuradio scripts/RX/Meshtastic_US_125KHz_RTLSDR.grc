options:
  parameters:
    author: Josh Conway (CrankyLinuxUser)
    description: This flow covers all presets at single frequency 904.438MHz , thus only needing a RTL-SDR.
    generate_options: qt_gui
    id: Meshtastic_125KHz_all
    output_language: python
    title: Meshtastic_125KHz_all
  states: {}

blocks:
- name: bandpass125k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_125bandwidth/2
    low_cutoff_freq: '-lora_125bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_125bandwidth/10
    win: window.WIN_HAMMING
  states: {}
- name: center_125KHz
  id: variable
  parameters:
    value: '904437500'
  states: {}
- name: cr_8
  id: variable
  parameters:
    value: '8'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: lora_125bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: payload_length
  id: variable
  parameters:
    value: '237'
  states: {}
- name: preamble_length
  id: variable
  parameters:
    value: '17'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: |-
      Technically the sync-word here for meshtastic is 0x2b
      Trying this leads to no data gathered.
      Using the [0,0] works.
    value: '[0,0]'
  states: {}
- name: blocks_tag_gate_0_3
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_4
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_125KHz
    comment: |-
      Set Minoutbuf = 17000
      Frame Sync needs that
    decim: int(samp_rate/(lora_125bandwidth * 4))
    minoutbuf: '17000'
    samp_rate: samp_rate
    taps: bandpass125k
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_sdr_crc_verif_0_3
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_4
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_deinterleaver_0_3
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_4
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0_3
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_4
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0_3
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_4
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0_3
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_125bandwidth
    center_freq: center_125KHz
    comment: |-
      LongModerate
      SF=11, CR=8, BW=125KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '11'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_4
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_125bandwidth
    center_freq: center_125KHz
    comment: |-
      LongSlow
      SF=12, CR=8, BW=125KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '12'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_mapping_0_3
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_4
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_3
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_4
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0_3
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_8
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_4
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_8
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: network_tcp_sink_0_3
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: LongModerate
    mode: '2'
    port: '20005'
    type: byte
  states: {}
- name: network_tcp_sink_0_4
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: LongSlow
    mode: '2'
    port: '20006'
    type: byte
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      This flow needs a dependency.
      https://github.com/tapparelj/gr-lora_sdr
    note: 'This flow needs a dependency: https://github.com/tapparelj/gr-lora_sdr'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_125KHz
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_tag_gate_0_3, '0', network_tcp_sink_0_3, '0']
- [blocks_tag_gate_0_4, '0', network_tcp_sink_0_4, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', lora_sdr_frame_sync_0_3, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', lora_sdr_frame_sync_0_4, '0']
- [lora_sdr_crc_verif_0_3, '0', blocks_tag_gate_0_3, '0']
- [lora_sdr_crc_verif_0_4, '0', blocks_tag_gate_0_4, '0']
- [lora_sdr_deinterleaver_0_3, '0', lora_sdr_hamming_dec_0_3, '0']
- [lora_sdr_deinterleaver_0_4, '0', lora_sdr_hamming_dec_0_4, '0']
- [lora_sdr_dewhitening_0_3, '0', lora_sdr_crc_verif_0_3, '0']
- [lora_sdr_dewhitening_0_4, '0', lora_sdr_crc_verif_0_4, '0']
- [lora_sdr_fft_demod_0_3, '0', lora_sdr_gray_mapping_0_3, '0']
- [lora_sdr_fft_demod_0_4, '0', lora_sdr_gray_mapping_0_4, '0']
- [lora_sdr_frame_sync_0_3, '0', lora_sdr_fft_demod_0_3, '0']
- [lora_sdr_frame_sync_0_4, '0', lora_sdr_fft_demod_0_4, '0']
- [lora_sdr_gray_mapping_0_3, '0', lora_sdr_deinterleaver_0_3, '0']
- [lora_sdr_gray_mapping_0_4, '0', lora_sdr_deinterleaver_0_4, '0']
- [lora_sdr_hamming_dec_0_3, '0', lora_sdr_header_decoder_0_3, '0']
- [lora_sdr_hamming_dec_0_4, '0', lora_sdr_header_decoder_0_4, '0']
- [lora_sdr_header_decoder_0_3, '0', lora_sdr_dewhitening_0_3, '0']
- [lora_sdr_header_decoder_0_3, frame_info, lora_sdr_frame_sync_0_3, frame_info]
- [lora_sdr_header_decoder_0_4, '0', lora_sdr_dewhitening_0_4, '0']
- [lora_sdr_header_decoder_0_4, frame_info, lora_sdr_frame_sync_0_4, frame_info]
- [rtlsdr_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
