options:
  parameters:
    author: Josh Conway (CrankyLinuxUser)
    description: This flow covers all presets at single frequency 906.875MHz , thus only needing a RTL-SDR.
    generate_options: qt_gui
    id: Meshtastic_250KHz_all
    output_language: python
    title: Meshtastic_250KHz_all
  states: {}

blocks:
- name: bandpass250k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_250bandwidth/2
    low_cutoff_freq: '-lora_250bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_250bandwidth/10
    win: window.WIN_HAMMING
  states: {}
- name: center_250KHz
  id: variable
  parameters:
    value: '869525000'
  states: {}
- name: cr_5
  id: variable
  parameters:
    value: '5'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: lora_250bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: payload_length
  id: variable
  parameters:
    value: '237'
  states: {}
- name: preamble_length
  id: variable
  parameters:
    value: '17'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: |-
      Technically the sync-word here for meshtastic is 0x2b
      Trying this leads to no data gathered.
      Using the [0,0] works.
    value: '[0,0]'
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_2
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_2_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_250KHz
    comment: |-
      Set Minoutbuf = 17000
      Frame Sync needs that
    decim: int(samp_rate/(lora_250bandwidth * 4))
    minoutbuf: '17000'
    samp_rate: samp_rate
    taps: bandpass250k
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_1
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_2
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_2_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_1
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_2
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_2_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_1
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_2
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_2_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_1
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_2
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_2_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      ShortFast
      SF=7, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '7'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      ShortSlow
      SF=8, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '8'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_1
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      MediumFast
      SF=9, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '9'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_2
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      MediumSlow
      SF=10,CR=5,BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '10'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_2_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      LongFast
      SF=11,CR=5,BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '11'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_1
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_2
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_2_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_1
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_2
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_2_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_1
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_2
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_2_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: ShortFast
    mode: '2'
    port: '20000'
    type: byte
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: ShortSlow
    mode: '2'
    port: '20001'
    type: byte
  states: {}
- name: network_tcp_sink_0_1
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: MediumFast
    mode: '2'
    port: '20002'
    type: byte
  states: {}
- name: network_tcp_sink_0_2
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: MediumSlow
    mode: '2'
    port: '20003'
    type: byte
  states: {}
- name: network_tcp_sink_0_2_0
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: LongFast
    mode: '2'
    port: '20004'
    type: byte
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      This flow needs a dependency.
      https://github.com/tapparelj/gr-lora_sdr
    note: 'This flow needs a dependency: https://github.com/tapparelj/gr-lora_sdr'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_250KHz
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_tag_gate_0, '0', network_tcp_sink_0, '0']
- [blocks_tag_gate_0_0, '0', network_tcp_sink_0_0, '0']
- [blocks_tag_gate_0_1, '0', network_tcp_sink_0_1, '0']
- [blocks_tag_gate_0_2, '0', network_tcp_sink_0_2, '0']
- [blocks_tag_gate_0_2_0, '0', network_tcp_sink_0_2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_2_0, '0']
- [lora_sdr_crc_verif_0, '0', blocks_tag_gate_0, '0']
- [lora_sdr_crc_verif_0_0, '0', blocks_tag_gate_0_0, '0']
- [lora_sdr_crc_verif_0_1, '0', blocks_tag_gate_0_1, '0']
- [lora_sdr_crc_verif_0_2, '0', blocks_tag_gate_0_2, '0']
- [lora_sdr_crc_verif_0_2_0, '0', blocks_tag_gate_0_2_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_deinterleaver_0_0, '0', lora_sdr_hamming_dec_0_0, '0']
- [lora_sdr_deinterleaver_0_1, '0', lora_sdr_hamming_dec_0_1, '0']
- [lora_sdr_deinterleaver_0_2, '0', lora_sdr_hamming_dec_0_2, '0']
- [lora_sdr_deinterleaver_0_2_0, '0', lora_sdr_hamming_dec_0_2_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_dewhitening_0_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_dewhitening_0_1, '0', lora_sdr_crc_verif_0_1, '0']
- [lora_sdr_dewhitening_0_2, '0', lora_sdr_crc_verif_0_2, '0']
- [lora_sdr_dewhitening_0_2_0, '0', lora_sdr_crc_verif_0_2_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_fft_demod_0_0, '0', lora_sdr_gray_mapping_0_0, '0']
- [lora_sdr_fft_demod_0_1, '0', lora_sdr_gray_mapping_0_1, '0']
- [lora_sdr_fft_demod_0_2, '0', lora_sdr_gray_mapping_0_2, '0']
- [lora_sdr_fft_demod_0_2_0, '0', lora_sdr_gray_mapping_0_2_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0_0, '0', lora_sdr_fft_demod_0_0, '0']
- [lora_sdr_frame_sync_0_1, '0', lora_sdr_fft_demod_0_1, '0']
- [lora_sdr_frame_sync_0_2, '0', lora_sdr_fft_demod_0_2, '0']
- [lora_sdr_frame_sync_0_2_0, '0', lora_sdr_fft_demod_0_2_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_gray_mapping_0_0, '0', lora_sdr_deinterleaver_0_0, '0']
- [lora_sdr_gray_mapping_0_1, '0', lora_sdr_deinterleaver_0_1, '0']
- [lora_sdr_gray_mapping_0_2, '0', lora_sdr_deinterleaver_0_2, '0']
- [lora_sdr_gray_mapping_0_2_0, '0', lora_sdr_deinterleaver_0_2_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_dec_0_0, '0', lora_sdr_header_decoder_0_0, '0']
- [lora_sdr_hamming_dec_0_1, '0', lora_sdr_header_decoder_0_1, '0']
- [lora_sdr_hamming_dec_0_2, '0', lora_sdr_header_decoder_0_2, '0']
- [lora_sdr_hamming_dec_0_2_0, '0', lora_sdr_header_decoder_0_2_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_header_decoder_0_0, '0', lora_sdr_dewhitening_0_0, '0']
- [lora_sdr_header_decoder_0_0, frame_info, lora_sdr_frame_sync_0_0, frame_info]
- [lora_sdr_header_decoder_0_1, '0', lora_sdr_dewhitening_0_1, '0']
- [lora_sdr_header_decoder_0_1, frame_info, lora_sdr_frame_sync_0_1, frame_info]
- [lora_sdr_header_decoder_0_2, '0', lora_sdr_dewhitening_0_2, '0']
- [lora_sdr_header_decoder_0_2, frame_info, lora_sdr_frame_sync_0_2, frame_info]
- [lora_sdr_header_decoder_0_2_0, '0', lora_sdr_dewhitening_0_2_0, '0']
- [lora_sdr_header_decoder_0_2_0, frame_info, lora_sdr_frame_sync_0_2_0, frame_info]
- [rtlsdr_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
