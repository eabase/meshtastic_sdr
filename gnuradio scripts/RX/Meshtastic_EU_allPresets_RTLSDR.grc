options:
  parameters:
    author: Josh Conway (CrankyLinuxUser)
    description: This flow covers all presets at multiple frequencies. EU bands are small, so a RTLSDR works!
    generate_options: qt_gui
    id: Meshtastic_allPresets_RTLSDR
    output_language: python
    title: Meshtastic_allPresets_RTLSDR
  states: {}

blocks:
- name: bandpass125k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_125bandwidth/2
    low_cutoff_freq: '-lora_125bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_125bandwidth/10
    win: window.WIN_HAMMING
  states: {}
- name: bandpass250k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_250bandwidth/2
    low_cutoff_freq: '-lora_250bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_250bandwidth/10
    win: window.WIN_HAMMING
  states: {}
- name: bandpass62k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_62bandwidth/2
    low_cutoff_freq: '-lora_62bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_62bandwidth/10
    win: window.WIN_HAMMING
  states: {}
- name: center_125KHz
  id: variable
  parameters:
    value: '869587500'
  states: {}
- name: center_250KHz
  id: variable
  parameters:
    value: '869525000'
  states: {}
- name: center_62KHz
  id: variable
  parameters:
    value: '869618800'
  states: {}
- name: cr_5
  id: variable
  parameters:
    value: '5'
  states: {}
- name: cr_8
  id: variable
  parameters:
    value: '8'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: lora_125bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: lora_250bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: lora_62bandwidth
  id: variable
  parameters:
    value: '62500'
  states: {}
- name: payload_length
  id: variable
  parameters:
    value: '237'
  states: {}
- name: preamble_length
  id: variable
  parameters:
    value: '17'
  states: {}
- name: radio_center_freq
  id: variable
  parameters:
    value: '869571900'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: |-
      Technically the sync-word here for meshtastic is 0x2b
      Trying this leads to no data gathered.
      Using the [0,0] works.
    value: '[0,0]'
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_2
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_2_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_3
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_4
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_4_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_250KHz - radio_center_freq
    comment: |-
      Set Minoutbuf = 17000
      Frame Sync needs that
    decim: int(samp_rate/(lora_250bandwidth * 4))
    minoutbuf: '17000'
    samp_rate: samp_rate
    taps: bandpass250k
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_125KHz - radio_center_freq
    comment: |-
      Set Minoutbuf = 17000
      Frame Sync needs that
    decim: int(samp_rate/(lora_125bandwidth * 4))
    minoutbuf: '17000'
    samp_rate: samp_rate
    taps: bandpass125k
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_62KHz - radio_center_freq
    comment: |-
      Set Minoutbuf = 17000
      Frame Sync needs that
    decim: int(samp_rate/(lora_62bandwidth * 4))
    minoutbuf: '17000'
    samp_rate: samp_rate
    taps: bandpass62k
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_1
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_2
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_2_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_3
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_4
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_4_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_1
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_2
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_2_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_3
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_4
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_4_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_1
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_2
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_2_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_3
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_4
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_4_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_1
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_2
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_2_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_3
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_4
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_4_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      ShortFast
      SF=7, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '7'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      ShortSlow
      SF=8, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '8'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_1
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      MediumFast
      SF=9, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '9'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_2
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      MediumSlow
      SF=10,CR=5,BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '10'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_2_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      LongFast
      SF=11,CR=5,BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '11'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_3
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_125bandwidth
    center_freq: center_125KHz
    comment: |-
      LongModerate
      SF=11, CR=8, BW=125KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '11'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_4
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_125bandwidth
    center_freq: center_125KHz
    comment: |-
      LongSlow
      SF=12, CR=8, BW=125KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '12'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_frame_sync_0_4_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_62bandwidth
    center_freq: center_62KHz
    comment: |-
      VeryLongSlow
      SF=12, CR=8, BW=62.5KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '12'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_1
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_2
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_2_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_3
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_4
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_4_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_1
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_2
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_2_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_3
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_4
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_4_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_1
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_2
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_2_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_5
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_3
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_8
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_4
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_8
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_4_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_8
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'False'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: ShortFast
    mode: '2'
    port: '20000'
    type: byte
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: ShortSlow
    mode: '2'
    port: '20001'
    type: byte
  states: {}
- name: network_tcp_sink_0_1
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: MediumFast
    mode: '2'
    port: '20002'
    type: byte
  states: {}
- name: network_tcp_sink_0_2
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: MediumSlow
    mode: '2'
    port: '20003'
    type: byte
  states: {}
- name: network_tcp_sink_0_2_0
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: LongFast
    mode: '2'
    port: '20004'
    type: byte
  states: {}
- name: network_tcp_sink_0_3
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: LongModerate
    mode: '2'
    port: '20005'
    type: byte
  states: {}
- name: network_tcp_sink_0_4
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: LongSlow
    mode: '2'
    port: '20006'
    type: byte
  states: {}
- name: network_tcp_sink_0_4_0
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    comment: VeryLongSlow
    mode: '2'
    port: '20007'
    type: byte
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      This flow needs a dependency.
      https://github.com/tapparelj/gr-lora_sdr
    note: 'This flow needs a dependency: https://github.com/tapparelj/gr-lora_sdr'
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      The radio_frequency_center is the center where the SDR tunes to.
      The 3 vars: center_250KHz, center_125KHz, and center_62KHz are absolute freqs
      The FIR filter extracts 4x the band size for LoRa processing.

      To get data programatically, connect to this machine's port TCP/20000-20007
    note: README
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: radio_center_freq
    dev_args: local:pluto.local
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_tag_gate_0, '0', network_tcp_sink_0, '0']
- [blocks_tag_gate_0_0, '0', network_tcp_sink_0_0, '0']
- [blocks_tag_gate_0_1, '0', network_tcp_sink_0_1, '0']
- [blocks_tag_gate_0_2, '0', network_tcp_sink_0_2, '0']
- [blocks_tag_gate_0_2_0, '0', network_tcp_sink_0_2_0, '0']
- [blocks_tag_gate_0_3, '0', network_tcp_sink_0_3, '0']
- [blocks_tag_gate_0_4, '0', network_tcp_sink_0_4, '0']
- [blocks_tag_gate_0_4_0, '0', network_tcp_sink_0_4_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', lora_sdr_frame_sync_0_3, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', lora_sdr_frame_sync_0_4, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', lora_sdr_frame_sync_0_4_0, '0']
- [lora_sdr_crc_verif_0, '0', blocks_tag_gate_0, '0']
- [lora_sdr_crc_verif_0_0, '0', blocks_tag_gate_0_0, '0']
- [lora_sdr_crc_verif_0_1, '0', blocks_tag_gate_0_1, '0']
- [lora_sdr_crc_verif_0_2, '0', blocks_tag_gate_0_2, '0']
- [lora_sdr_crc_verif_0_2_0, '0', blocks_tag_gate_0_2_0, '0']
- [lora_sdr_crc_verif_0_3, '0', blocks_tag_gate_0_3, '0']
- [lora_sdr_crc_verif_0_4, '0', blocks_tag_gate_0_4, '0']
- [lora_sdr_crc_verif_0_4_0, '0', blocks_tag_gate_0_4_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_deinterleaver_0_0, '0', lora_sdr_hamming_dec_0_0, '0']
- [lora_sdr_deinterleaver_0_1, '0', lora_sdr_hamming_dec_0_1, '0']
- [lora_sdr_deinterleaver_0_2, '0', lora_sdr_hamming_dec_0_2, '0']
- [lora_sdr_deinterleaver_0_2_0, '0', lora_sdr_hamming_dec_0_2_0, '0']
- [lora_sdr_deinterleaver_0_3, '0', lora_sdr_hamming_dec_0_3, '0']
- [lora_sdr_deinterleaver_0_4, '0', lora_sdr_hamming_dec_0_4, '0']
- [lora_sdr_deinterleaver_0_4_0, '0', lora_sdr_hamming_dec_0_4_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_dewhitening_0_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_dewhitening_0_1, '0', lora_sdr_crc_verif_0_1, '0']
- [lora_sdr_dewhitening_0_2, '0', lora_sdr_crc_verif_0_2, '0']
- [lora_sdr_dewhitening_0_2_0, '0', lora_sdr_crc_verif_0_2_0, '0']
- [lora_sdr_dewhitening_0_3, '0', lora_sdr_crc_verif_0_3, '0']
- [lora_sdr_dewhitening_0_4, '0', lora_sdr_crc_verif_0_4, '0']
- [lora_sdr_dewhitening_0_4_0, '0', lora_sdr_crc_verif_0_4_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_fft_demod_0_0, '0', lora_sdr_gray_mapping_0_0, '0']
- [lora_sdr_fft_demod_0_1, '0', lora_sdr_gray_mapping_0_1, '0']
- [lora_sdr_fft_demod_0_2, '0', lora_sdr_gray_mapping_0_2, '0']
- [lora_sdr_fft_demod_0_2_0, '0', lora_sdr_gray_mapping_0_2_0, '0']
- [lora_sdr_fft_demod_0_3, '0', lora_sdr_gray_mapping_0_3, '0']
- [lora_sdr_fft_demod_0_4, '0', lora_sdr_gray_mapping_0_4, '0']
- [lora_sdr_fft_demod_0_4_0, '0', lora_sdr_gray_mapping_0_4_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0_0, '0', lora_sdr_fft_demod_0_0, '0']
- [lora_sdr_frame_sync_0_1, '0', lora_sdr_fft_demod_0_1, '0']
- [lora_sdr_frame_sync_0_2, '0', lora_sdr_fft_demod_0_2, '0']
- [lora_sdr_frame_sync_0_2_0, '0', lora_sdr_fft_demod_0_2_0, '0']
- [lora_sdr_frame_sync_0_3, '0', lora_sdr_fft_demod_0_3, '0']
- [lora_sdr_frame_sync_0_4, '0', lora_sdr_fft_demod_0_4, '0']
- [lora_sdr_frame_sync_0_4_0, '0', lora_sdr_fft_demod_0_4_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_gray_mapping_0_0, '0', lora_sdr_deinterleaver_0_0, '0']
- [lora_sdr_gray_mapping_0_1, '0', lora_sdr_deinterleaver_0_1, '0']
- [lora_sdr_gray_mapping_0_2, '0', lora_sdr_deinterleaver_0_2, '0']
- [lora_sdr_gray_mapping_0_2_0, '0', lora_sdr_deinterleaver_0_2_0, '0']
- [lora_sdr_gray_mapping_0_3, '0', lora_sdr_deinterleaver_0_3, '0']
- [lora_sdr_gray_mapping_0_4, '0', lora_sdr_deinterleaver_0_4, '0']
- [lora_sdr_gray_mapping_0_4_0, '0', lora_sdr_deinterleaver_0_4_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_dec_0_0, '0', lora_sdr_header_decoder_0_0, '0']
- [lora_sdr_hamming_dec_0_1, '0', lora_sdr_header_decoder_0_1, '0']
- [lora_sdr_hamming_dec_0_2, '0', lora_sdr_header_decoder_0_2, '0']
- [lora_sdr_hamming_dec_0_2_0, '0', lora_sdr_header_decoder_0_2_0, '0']
- [lora_sdr_hamming_dec_0_3, '0', lora_sdr_header_decoder_0_3, '0']
- [lora_sdr_hamming_dec_0_4, '0', lora_sdr_header_decoder_0_4, '0']
- [lora_sdr_hamming_dec_0_4_0, '0', lora_sdr_header_decoder_0_4_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_header_decoder_0_0, '0', lora_sdr_dewhitening_0_0, '0']
- [lora_sdr_header_decoder_0_0, frame_info, lora_sdr_frame_sync_0_0, frame_info]
- [lora_sdr_header_decoder_0_1, '0', lora_sdr_dewhitening_0_1, '0']
- [lora_sdr_header_decoder_0_1, frame_info, lora_sdr_frame_sync_0_1, frame_info]
- [lora_sdr_header_decoder_0_2, '0', lora_sdr_dewhitening_0_2, '0']
- [lora_sdr_header_decoder_0_2, frame_info, lora_sdr_frame_sync_0_2, frame_info]
- [lora_sdr_header_decoder_0_2_0, '0', lora_sdr_dewhitening_0_2_0, '0']
- [lora_sdr_header_decoder_0_2_0, frame_info, lora_sdr_frame_sync_0_2_0, frame_info]
- [lora_sdr_header_decoder_0_3, '0', lora_sdr_dewhitening_0_3, '0']
- [lora_sdr_header_decoder_0_3, frame_info, lora_sdr_frame_sync_0_3, frame_info]
- [lora_sdr_header_decoder_0_4, '0', lora_sdr_dewhitening_0_4, '0']
- [lora_sdr_header_decoder_0_4, frame_info, lora_sdr_frame_sync_0_4, frame_info]
- [lora_sdr_header_decoder_0_4_0, '0', lora_sdr_dewhitening_0_4_0, '0']
- [lora_sdr_header_decoder_0_4_0, frame_info, lora_sdr_frame_sync_0_4_0, frame_info]
- [soapy_plutosdr_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
