options:
  parameters:
    author: Tapparel Joachim@EPFL,TCL
    generate_options: qt_gui
    id: lora_TX
    output_language: python
  states: {}

blocks:
- name: bandpass250k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_250bandwidth/2
    low_cutoff_freq: '-lora_250bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_250bandwidth/50
    win: window.WIN_HAMMING
  states: {}
- name: center_250KHz
  id: variable
  parameters:
    value: '906875000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '906875000'
  states: {}
- name: cr_44
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr_45
  id: variable
  parameters:
    value: '1'
  states: {}
- name: cr_46
  id: variable
  parameters:
    value: '2'
  states: {}
- name: cr_47
  id: variable
  parameters:
    value: '3'
  states: {}
- name: cr_48
  id: variable
  parameters:
    value: '8'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: lora_250bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: preamble_length
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sf_11
  id: variable
  parameters:
    value: '11'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: |-
      Technically the sync-word here for meshtastic is 0x2b
      Trying this leads to no data gathered.
      Using the [0,0] works.
    value: '[16,88]'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf_11
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr_45
    sf: sf_11
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr_45
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: lora_250bandwidth
    cr: cr_45
    ldro: '2'
    sf: '11'
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: lora_250bandwidth
    frame_zero_padd: int(20*2**sf_11*samp_rate/lora_250bandwidth)
    minoutbuf: '8200'
    preamb_len: preamble_length
    samp_rate: samp_rate
    sf: sf_11
    sync_words: sync_word
  states: {}
- name: lora_sdr_whitening_0_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_250KHz
    fftsize: '32768'
    name: '"Channel Model"'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    dev_args: hackrf=0
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://0.0.0.0:30004
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', soapy_hackrf_sink_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', blocks_throttle2_0, '0']
- [lora_sdr_whitening_0_0, '0', lora_sdr_header_0, '0']
- [zeromq_pull_msg_source_0, out, lora_sdr_whitening_0_0, msg]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
